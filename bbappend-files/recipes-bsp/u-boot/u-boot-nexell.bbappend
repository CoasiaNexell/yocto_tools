### Nexell - For Yocto build with using local source, Below lines are auto generated codes

PV = "1.0+EXTERNAL_SRC"

EXTERNALSRC = "${_SRC_PATH_BY_GEN_}"
EXTERNALSRC_BUILD = "${_SRC_PATH_BY_GEN_}"

S = "${WORKDIR}/${_SRC_PATH_BY_GEN_}"


SRC_URI="file://${_SRC_PATH_BY_GEN_}"

_SRC_PATH_BY_GEN_?="/home/ray/work2/yocto-btc08/u-boot/u-boot-2016.01"